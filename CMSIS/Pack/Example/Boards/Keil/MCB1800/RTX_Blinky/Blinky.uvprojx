# Keil uVision project Blinky.uvprojx, settings and files
target LPC1857 Flash (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C://Keil5/ARM/PACK/Keil/LPC1800_DFP/1.99.12/Boards/Keil/MCB1800/Common/: LED_MCB1800.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C://Keil5/ARM/PACK/ARM/CMSIS/4.0.11/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group ::Device
    RTE/Device/LPC1857/: RTE_Device.h startup_LPC18xx.s system_LPC18xx.c
    C://Keil5/ARM/PACK/Keil/LPC1800_DFP/1.99.12/RTE_Driver/: GPIO_LPC18xx.c SCU_LPC18xx.c
target LPC1857 RAM (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.30.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:LED 1.00, Device:GPIO 1.00, Device:SCU 1.00, Device:Startup 1.0.0
