# Keil uVision project arm_graphic_equalizer_example.uvprojx, settings and files
target ARMCM0 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.1.10
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1
  c define: ARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: math_helper.c arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c
  group Documentation
    ./: Abstract.txt
  group ::CMSIS
    C:/Keil/ARM/PACK/ARM/CMSIS/4.1.10/CMSIS/Lib/ARM/: arm_cortexM0l_math.lib arm_cortexM3l_math.lib arm_cortexM4lf_math.lib arm_cortexM7lfsp_math.lib
  group ::Device
    RTE/Device/ARMCM0/: startup_ARMCM0.s system_ARMCM0.c
    RTE/Device/ARMCM3/: startup_ARMCM3.s system_ARMCM3.c
    RTE/Device/ARMCM4_FP/: startup_ARMCM4.s system_ARMCM4.c
    RTE/Device/ARMCM7_SP/: startup_ARMCM7.s system_ARMCM7.c
target ARMCM3 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.1.10
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(10000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1
  c define: ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM4_FP (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.1.10
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1
  c define: ARM_MATH_CM4 __FPU_PRESENT=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM7_SP (ARM-ADS)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.4.1.10
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1
  c define: ARM_MATH_CM7 __FPU_PRESENT=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1
