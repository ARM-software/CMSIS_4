# Keil uVision project arm_fft_bin_example.uvproj, settings and files
target ARMCM0 (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: arm_fft_bin_example
  group Source Files
    ./: arm_fft_bin_example_f32.c arm_fft_bin_data.c
  group CMSIS Device
    ./Startup/: startup_ARMCM0.S system_ARMCM0.c startup_ARMCM3.S system_ARMCM3.c startup_ARMCM4.S system_ARMCM4.c
target ARMCM3 (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: arm_fft_bin_example
target ARMCM4_FP (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_fft_bin_example
