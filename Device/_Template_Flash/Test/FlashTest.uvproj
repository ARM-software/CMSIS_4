# Keil uVision project FlashTest.uvproj, settings and files
target STM32F103 Flash Test (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Test
  c flags: Optim=1
  c include: ..\; ..\..\
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x3000
  group Startup Code
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Flash Algorithm Files
    ./: FlashDev.c FlashPrg.c
  group Source Files
    ./: FlashTest.c
  group Documentation
    ./: Abstract.txt
